# Keil uVision project liangcang.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\usart;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\BEEP;..\HARDWARE\ADC_DMA;..\HARDWARE\TIMER;..\HARDWARE\DHT11;..\HARDWARE\HC_SR04;..\HARDWARE\HC_SR501;..\HARDWARE\TFT;..\HARDWARE\MQ-135;..\HARDWARE\NET\device;..\HARDWARE\NET\MQTT;..\HARDWARE\NET\onenet;..\USER;..\STM32F10x_FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\motor;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC_DMA/: adc_dma.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/HC_SR04/: hc_sr04.c
    ../HARDWARE/HC_SR501/: hc_sr501.c
    ../HARDWARE/MQ-135/: mq135.c
    ../HARDWARE/TFT/: gui.c lcd.c
    ../HARDWARE/NET/device/: esp8266.c
    ../HARDWARE/motor/: motor.c
  group NET
    ../HARDWARE/NET/MQTT/: MqttKit.c
    ../HARDWARE/NET/onenet/: onenet.c
